# IAR project Backup of QYProject.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2129 NXP LPC2129
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: Library\CPU; Library\Drivers\ADC; Library\Drivers\UART; Library\Drivers\GPIO; Library\Drivers\PIT; Library\Drivers\PWM; Library\Drivers\SPI; Library\Drivers\CAN; MyFunction
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: QYProject.out
  ILINK.IlinkIcfFile: Linker\LPC2129_Program_in_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Library/CPU
    Library/CPU/: intrinsics.h io_macros.h iolpc2119.h iolpc2129.h Vector.c Vector.h ycheck.h
  group Library/Driver/ADC
    Library/Drivers/ADC/: ADC.c ADC.h
  group Library/Driver/CAN
    Library/Drivers/CAN/: CAN.c CAN.h
  group Library/Driver/GPIO
    Library/Drivers/GPIO/: GPIO.c GPIO.h
  group Library/Driver/PIT
    Library/Drivers/PIT/: PIT.c PIT.h
  group Library/Driver/PWM
    Library/Drivers/PWM/: PWM.c PWM.h
  group Library/Driver/SPI
    Library/Drivers/SPI/: SPI.c SPI.h
  group Library/Driver/UART
    Library/Drivers/UART/: UART.c UART.h
  group MyFunction/Angle_PID
    MyFunction/: Angle_PID.c Angle_PID.h
  group MyFunction/Headers
    MyFunction/: headers.h Macro.h
  group MyFunction/Source
    MyFunction/: ADCF.c ADCF.h main.c
  group MyFunction/Source/Interrupt_Function
    MyFunction/: Interrupt.c Interrupt.h
  group MyFunction/System_Init
    MyFunction/: System_Init.c System_Init.h
